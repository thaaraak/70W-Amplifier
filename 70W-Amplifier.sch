File: 70W-Amplifier.sch (KiCad schematic (older format))
At the start: 44 parts, among them J1 RF_OUT, J2 RF_IN, J3 LPF_IN, J4 LPF_OUT, J5 13.8V Input, J6 PTT, K1 G5V-2, Q1 2N3906-SMD, Q2 IRF530, Q3 IRF530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

Commit message: fixed diode
Parts:
- removed BIAS_IN1, BIAS_OUT1: Conn_01x01, Connector_PinHeader_1.00mm:PinHeader_1x01_P1.00mm_Vertical, symbol Connector_Generic:Conn_01x01
- added J7: Conn_01x02, Xenir:PinPad, symbol Connector_Generic:Conn_01x02
- added J8: Conn_01x02, Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical, symbol Connector_Generic:Conn_01x02
- R7: value 1k -> 180
Connections:
- wire segments 82 -> 87
Changed lines of the file:
@@
 P 7400 1700
 F 0 "R7" H 7400 1546 28  0000 C CNN
-F 1 "1k" H 7400 1603 28  0000 C CNN
+F 1 "180" H 7400 1603 28  0000 C CNN
 F 2 "Xenir:Resistor 1206" H 7400 1600 50  0001 C CNN
 F 3 "" H 7400 1600 50  0001 C CNN
@@
 	10000 2450 10000 2750
 $Comp
-L Connector_Generic:Conn_01x01 BIAS_IN1
-U 1 1 61EAA0AE
-P 8900 2450
-F 0 "BIAS_IN1" H 9000 2250 50  0000 C CNN
-F 1 "Conn_01x01" H 9000 2350 50  0000 C CNN
-F 2 "Connector_PinHeader_1.00mm:PinHeader_1x01_P1.00mm_Vertical" H 8900 2450 50  0001 C CNN
-F 3 "~" H 8900 2450 50  0001 C CNN
-	1    8900 2450
-	-1   0    0    1
-$EndComp
-$Comp
-L Connector_Generic:Conn_01x01 BIAS_OUT1
-U 1 1 61EAB06B
-P 8900 2750
-F 0 "BIAS_OUT1" H 9000 2850 50  0000 C CNN
-F 1 "Conn_01x01" H 9000 2950 50  0000 C CNN
-F 2 "Connector_PinHeader_1.00mm:PinHeader_1x01_P1.00mm_Vertical" H 8900 2750 50  0001 C CNN
-F 3 "~" H 8900 2750 50  0001 C CNN
-	1    8900 2750
-	-1   0    0    1
-$EndComp
+L Connector_Generic:Conn_01x02 J7
+U 1 1 61E9AA01
+P 7700 1200
+F 0 "J7" V 7664 1012 50  0000 R CNN
+F 1 "Conn_01x02" V 7573 1012 50  0000 R CNN
+F 2 "Xenir:PinPad" H 7700 1200 50  0001 C CNN
+F 3 "~" H 7700 1200 50  0001 C CNN
+	1    7700 1200
+	0    -1   -1   0
+$EndComp
+$Comp
+L power:GND #PWR0102
+U 1 1 61EB24D8
+P 7800 1400
+F 0 "#PWR0102" H 7800 1150 50  0001 C CNN
+F 1 "GND" H 7805 1227 50  0000 C CNN
+F 2 "" H 7800 1400 50  0001 C CNN
+F 3 "" H 7800 1400 50  0001 C CNN
+	1    7800 1400
+	1    0    0    -1
+$EndComp
+Wire Wire Line
+	7700 1400 7700 1700
+$Comp
+L Connector_Generic:Conn_01x02 J8
+U 1 1 61EB4D4F
+P 8750 2650
+F 0 "J8" H 8668 2325 50  0000 C CNN
+F 1 "Conn_01x02" H 8668 2416 50  0000 C CNN
+F 2 "Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical" H 8750 2650 50  0001 C CNN
+F 3 "~" H 8750 2650 50  0001 C CNN
+	1    8750 2650
+	-1   0    0    1
+$EndComp
+Wire Wire Line
+	8950 2550 8950 2450
+Wire Wire Line
+	8950 2450 9100 2450
+Wire Wire Line
+	9100 2750 8950 2750
+Wire Wire Line
+	8950 2750 8950 2650
 $EndSCHEMATC

Commit message: changed diode to sod-123
Parts:
- D2, D3, D4, D5, D6, D7: footprint Diode_SMD:D_SOD-323 -> Diode_SMD:D_SOD-123
Changed lines of the file:
@@
 F 0 "D2" H 9250 2233 50  0000 C CNN
 F 1 "1N914" H 9250 2324 50  0000 C CNN
-F 2 "Diode_SMD:D_SOD-323" H 9250 2275 50  0001 C CNN
+F 2 "Diode_SMD:D_SOD-123" H 9250 2275 50  0001 C CNN
 F 3 "http://www.vishay.com/docs/85622/1n914.pdf" H 9250 2450 50  0001 C CNN
 	1    9250 2450
@@
 F 0 "D4" H 9550 2233 50  0000 C CNN
 F 1 "1N914" H 9550 2324 50  0000 C CNN
-F 2 "Diode_SMD:D_SOD-323" H 9550 2275 50  0001 C CNN
+F 2 "Diode_SMD:D_SOD-123" H 9550 2275 50  0001 C CNN
 F 3 "http://www.vishay.com/docs/85622/1n914.pdf" H 9550 2450 50  0001 C CNN
 	1    9550 2450
@@
 F 0 "D6" H 9850 2233 50  0000 C CNN
 F 1 "1N914" H 9850 2324 50  0000 C CNN
-F 2 "Diode_SMD:D_SOD-323" H 9850 2275 50  0001 C CNN
+F 2 "Diode_SMD:D_SOD-123" H 9850 2275 50  0001 C CNN
 F 3 "http://www.vishay.com/docs/85622/1n914.pdf" H 9850 2450 50  0001 C CNN
 	1    9850 2450
@@
 F 0 "D7" H 9850 2967 50  0000 C CNN
 F 1 "1N914" H 9850 2876 50  0000 C CNN
-F 2 "Diode_SMD:D_SOD-323" H 9850 2575 50  0001 C CNN
+F 2 "Diode_SMD:D_SOD-123" H 9850 2575 50  0001 C CNN
 F 3 "http://www.vishay.com/docs/85622/1n914.pdf" H 9850 2750 50  0001 C CNN
 	1    9850 2750
@@
 F 0 "D5" H 9550 2967 50  0000 C CNN
 F 1 "1N914" H 9550 2876 50  0000 C CNN
-F 2 "Diode_SMD:D_SOD-323" H 9550 2575 50  0001 C CNN
+F 2 "Diode_SMD:D_SOD-123" H 9550 2575 50  0001 C CNN
 F 3 "http://www.vishay.com/docs/85622/1n914.pdf" H 9550 2750 50  0001 C CNN
 	1    9550 2750
@@
 F 0 "D3" H 9250 2967 50  0000 C CNN
 F 1 "1N914" H 9250 2876 50  0000 C CNN
-F 2 "Diode_SMD:D_SOD-323" H 9250 2575 50  0001 C CNN
+F 2 "Diode_SMD:D_SOD-123" H 9250 2575 50  0001 C CNN
 F 3 "http://www.vishay.com/docs/85622/1n914.pdf" H 9250 2750 50  0001 C CNN
 	1    9250 2750

Commit message: shrank board
Parts:
- D1: footprint Diode_THT:D_DO-35_SOD27_P7.62mm_Horizontal -> Diode_SMD:D_SOD-123
Changed lines of the file:
@@
 F 0 "D1" H 3450 3467 50  0000 C CNN
 F 1 "1N4148" H 3450 3376 50  0000 C CNN
-F 2 "Diode_THT:D_DO-35_SOD27_P7.62mm_Horizontal" H 3450 3075 50  0001 C CNN
+F 2 "Diode_SMD:D_SOD-123" H 3450 3075 50  0001 C CNN
 F 3 "https://assets.nexperia.com/documents/data-sheet/1N4148_1N4448.pdf" H 3450 3250 50  0001 C CNN
 	1    3450 3250

Commit message: gg
Parts:
- C1, C2, C3, C4, C5, C6, C7, C8: symbol Xenir:Capacitor -> 70W-Amplifier-rescue:Capacitor-Xenir
- EC1, EC2: symbol Xenir:Cap_Polarized -> 70W-Amplifier-rescue:Cap_Polarized-Xenir
- J1, J2: symbol Xenir:BNC -> 70W-Amplifier-rescue:BNC-Xenir
- J3, J4: symbol Xenir:PCB_SMA_EDGE -> 70W-Amplifier-rescue:PCB_SMA_EDGE-Xenir
- L1: symbol Xenir:Inductor -> 70W-Amplifier-rescue:Inductor-Xenir
- Q1: symbol Xenir:2N3906-SMD -> 70W-Amplifier-rescue:2N3906-SMD-Xenir
- R1, R2, R3, R4, R5, R6, R7, R8, R9: symbol Xenir:Resistor -> 70W-Amplifier-rescue:Resistor-Xenir
- T1, T2: symbol Xenir:Splitter_Center_Tap -> 70W-Amplifier-rescue:Splitter_Center_Tap-Xenir
Changed lines of the file:
@@
 $EndComp
 $Comp
-L Xenir:Resistor R1
+L 70W-Amplifier-rescue:Resistor-Xenir R1
 U 1 1 61C4B77E
 P 4950 2150
@@
 $EndComp
 $Comp
-L Xenir:Resistor R2
+L 70W-Amplifier-rescue:Resistor-Xenir R2
 U 1 1 61C4D74C
 P 5300 2450
@@
 	5300 2150 5300 2250
 $Comp
-L Xenir:Cap_Polarized EC2
+L 70W-Amplifier-rescue:Cap_Polarized-Xenir EC2
 U 1 1 61C4EC77
 P 7100 1950
@@
 $EndComp
 $Comp
-L Xenir:Cap_Polarized EC1
+L 70W-Amplifier-rescue:Cap_Polarized-Xenir EC1
 U 1 1 61C4FE0A
 P 4300 1950
@@
 $EndComp
 $Comp
-L Xenir:Resistor R7
+L 70W-Amplifier-rescue:Resistor-Xenir R7
 U 1 1 61C5E001
 P 7400 1700
@@
 $EndComp
 $Comp
-L Xenir:Capacitor C2
+L 70W-Amplifier-rescue:Capacitor-Xenir C2
 U 1 1 61C5E84F
 P 7700 1950
@@
 	8350 1950 8450 1950
 $Comp
-L Xenir:BNC J2
+L 70W-Amplifier-rescue:BNC-Xenir J2
 U 1 1 61C68424
 P 2200 4650
@@
 $EndComp
 $Comp
-L Xenir:BNC J1
+L 70W-Amplifier-rescue:BNC-Xenir J1
 U 1 1 61C69914
 P 1800 4250
@@
 	5350 4350 5350 4450
 $Comp
-L Xenir:Resistor R3
+L 70W-Amplifier-rescue:Resistor-Xenir R3
 U 1 1 61CCDCF5
 P 5700 4550
@@
 $EndComp
 $Comp
-L Xenir:Capacitor C3
+L 70W-Amplifier-rescue:Capacitor-Xenir C3
 U 1 1 61CCE86F
 P 6050 4500
@@
 	5350 4950 6400 4950
 $Comp
-L Xenir:Resistor R4
+L 70W-Amplifier-rescue:Resistor-Xenir R4
 U 1 1 61CDA054
 P 6750 3300
@@
 $EndComp
 $Comp
-L Xenir:Capacitor C4
+L 70W-Amplifier-rescue:Capacitor-Xenir C4
 U 1 1 61CDADD3
 P 6400 3600
@@
 	6400 3950 6650 3950
 $Comp
-L Xenir:Capacitor C5
+L 70W-Amplifier-rescue:Capacitor-Xenir C5
 U 1 1 61CDF56C
 P 6400 5350
@@
 $EndComp
 $Comp
-L Xenir:Resistor R5
+L 70W-Amplifier-rescue:Resistor-Xenir R5
 U 1 1 61CDFD89
 P 6750 5700
@@
 	8200 4350 8200 4450
 $Comp
-L Xenir:Capacitor C1
+L 70W-Amplifier-rescue:Capacitor-Xenir C1
 U 1 1 61CECBAC
 P 7850 4500
@@
 LPF
 $Comp
-L Xenir:Inductor L1
+L 70W-Amplifier-rescue:Inductor-Xenir L1
 U 1 1 61D26F6D
 P 7850 4000
@@
 	6050 4350 6050 4250
 $Comp
-L Xenir:Resistor R6
+L 70W-Amplifier-rescue:Resistor-Xenir R6
 U 1 1 61C90F87
 P 6400 4400
@@
 	6400 4950 6400 4600
 $Comp
-L Xenir:Splitter_Center_Tap T1
+L 70W-Amplifier-rescue:Splitter_Center_Tap-Xenir T1
 U 1 1 61CE4121
 P 5000 3850
@@
 	5350 4850 5350 4950
 $Comp
-L Xenir:2N3906-SMD Q1
+L 70W-Amplifier-rescue:2N3906-SMD-Xenir Q1
 U 1 1 61CF1527
 P 5300 1800
@@
 $EndComp
 $Comp
-L Xenir:PCB_SMA_EDGE J3
+L 70W-Amplifier-rescue:PCB_SMA_EDGE-Xenir J3
 U 1 1 61CF5952
 P 9650 4350
@@
 $EndComp
 $Comp
-L Xenir:PCB_SMA_EDGE J4
+L 70W-Amplifier-rescue:PCB_SMA_EDGE-Xenir J4
 U 1 1 61CF9C6B
 P 10500 4350
@@
 $EndComp
 $Comp
-L Xenir:Splitter_Center_Tap T2
+L 70W-Amplifier-rescue:Splitter_Center_Tap-Xenir T2
 U 1 1 61CFF29A
 P 8550 5050
@@
 Q3Drain
 $Comp
-L Xenir:Resistor R8
+L 70W-Amplifier-rescue:Resistor-Xenir R8
 U 1 1 61E660AB
 P 7150 4150
@@
 $EndComp
 $Comp
-L Xenir:Resistor R9
+L 70W-Amplifier-rescue:Resistor-Xenir R9
 U 1 1 61E6F0FA
 P 7150 4750
@@
 $EndComp
 $Comp
-L Xenir:Capacitor C6
+L 70W-Amplifier-rescue:Capacitor-Xenir C6
 U 1 1 61E6FCAB
 P 7100 4325
@@
 $EndComp
 $Comp
-L Xenir:Capacitor C7
+L 70W-Amplifier-rescue:Capacitor-Xenir C7
 U 1 1 61E706E7
 P 7100 4550
@@
 	7350 4550 7350 4450
 $Comp
-L Xenir:Capacitor C8
+L 70W-Amplifier-rescue:Capacitor-Xenir C8
 U 1 1 61E9AE04
 P 9050 4750

Commit message: addedf R6
Parts:
- R6: value Varies According to Band -> 18
Other:
- note added: "https://pa-11019.blogspot.com/2016/11/diy-kits-70w-ssb-linear-hf-power.html"

Commit message: added
Parts:
- C1, C2, C3, C4, C5, C6, C7, C8: symbol 70W-Amplifier-rescue:Capacitor-Xenir -> 70W-Amplifier-rescue:Capacitor-Xenir-70W-Amplifier-rescue
- EC1, EC2: symbol 70W-Amplifier-rescue:Cap_Polarized-Xenir -> 70W-Amplifier-rescue:Cap_Polarized-Xenir-70W-Amplifier-rescue
- J1, J2: symbol 70W-Amplifier-rescue:BNC-Xenir -> 70W-Amplifier-rescue:BNC-Xenir-70W-Amplifier-rescue
- J3, J4: symbol 70W-Amplifier-rescue:PCB_SMA_EDGE-Xenir -> 70W-Amplifier-rescue:PCB_SMA_EDGE-Xenir-70W-Amplifier-rescue
- L1: symbol 70W-Amplifier-rescue:Inductor-Xenir -> 70W-Amplifier-rescue:Inductor-Xenir-70W-Amplifier-rescue
- Q1: symbol 70W-Amplifier-rescue:2N3906-SMD-Xenir -> 70W-Amplifier-rescue:2N3906-SMD-Xenir-70W-Amplifier-rescue
- R1, R2, R3, R4, R5, R6, R7, R8, R9: symbol 70W-Amplifier-rescue:Resistor-Xenir -> 70W-Amplifier-rescue:Resistor-Xenir-70W-Amplifier-rescue
- T1, T2: symbol 70W-Amplifier-rescue:Splitter_Center_Tap-Xenir -> 70W-Amplifier-rescue:Splitter_Center_Tap-Xenir-70W-Amplifier-rescue
Changed lines of the file:
@@
 $EndComp
 $Comp
-L 70W-Amplifier-rescue:Resistor-Xenir R1
+L 70W-Amplifier-rescue:Resistor-Xenir-70W-Amplifier-rescue R1
 U 1 1 61C4B77E
 P 4950 2150
@@
 $EndComp
 $Comp
-L 70W-Amplifier-rescue:Resistor-Xenir R2
+L 70W-Amplifier-rescue:Resistor-Xenir-70W-Amplifier-rescue R2
 U 1 1 61C4D74C
 P 5300 2450
@@
 	5300 2150 5300 2250
 $Comp
-L 70W-Amplifier-rescue:Cap_Polarized-Xenir EC2
+L 70W-Amplifier-rescue:Cap_Polarized-Xenir-70W-Amplifier-rescue EC2
 U 1 1 61C4EC77
 P 7100 1950
@@
 $EndComp
 $Comp
-L 70W-Amplifier-rescue:Cap_Polarized-Xenir EC1
+L 70W-Amplifier-rescue:Cap_Polarized-Xenir-70W-Amplifier-rescue EC1
 U 1 1 61C4FE0A
 P 4300 1950
@@
 $EndComp
 $Comp
-L 70W-Amplifier-rescue:Resistor-Xenir R7
+L 70W-Amplifier-rescue:Resistor-Xenir-70W-Amplifier-rescue R7
 U 1 1 61C5E001
 P 7400 1700
@@
 $EndComp
 $Comp
-L 70W-Amplifier-rescue:Capacitor-Xenir C2
+L 70W-Amplifier-rescue:Capacitor-Xenir-70W-Amplifier-rescue C2
 U 1 1 61C5E84F
 P 7700 1950
@@
 	8350 1950 8450 1950
 $Comp
-L 70W-Amplifier-rescue:BNC-Xenir J2
+L 70W-Amplifier-rescue:BNC-Xenir-70W-Amplifier-rescue J2
 U 1 1 61C68424
 P 2200 4650
@@
 $EndComp
 $Comp
-L 70W-Amplifier-rescue:BNC-Xenir J1
+L 70W-Amplifier-rescue:BNC-Xenir-70W-Amplifier-rescue J1
 U 1 1 61C69914
 P 1800 4250
@@
 	5350 4350 5350 4450
 $Comp
-L 70W-Amplifier-rescue:Resistor-Xenir R3
+L 70W-Amplifier-rescue:Resistor-Xenir-70W-Amplifier-rescue R3
 U 1 1 61CCDCF5
 P 5700 4550
@@
 $EndComp
 $Comp
-L 70W-Amplifier-rescue:Capacitor-Xenir C3
+L 70W-Amplifier-rescue:Capacitor-Xenir-70W-Amplifier-rescue C3
 U 1 1 61CCE86F
 P 6050 4500
@@
 	5350 4950 6400 4950
 $Comp
-L 70W-Amplifier-rescue:Resistor-Xenir R4
+L 70W-Amplifier-rescue:Resistor-Xenir-70W-Amplifier-rescue R4
 U 1 1 61CDA054
 P 6750 3300
@@
 $EndComp
 $Comp
-L 70W-Amplifier-rescue:Capacitor-Xenir C4
+L 70W-Amplifier-rescue:Capacitor-Xenir-70W-Amplifier-rescue C4
 U 1 1 61CDADD3
 P 6400 3600
@@
 	6400 3950 6650 3950
 $Comp
-L 70W-Amplifier-rescue:Capacitor-Xenir C5
+L 70W-Amplifier-rescue:Capacitor-Xenir-70W-Amplifier-rescue C5
 U 1 1 61CDF56C
 P 6400 5350
@@
 $EndComp
 $Comp
-L 70W-Amplifier-rescue:Resistor-Xenir R5
+L 70W-Amplifier-rescue:Resistor-Xenir-70W-Amplifier-rescue R5
 U 1 1 61CDFD89
 P 6750 5700
@@
 	8200 4350 8200 4450
 $Comp
-L 70W-Amplifier-rescue:Capacitor-Xenir C1
+L 70W-Amplifier-rescue:Capacitor-Xenir-70W-Amplifier-rescue C1
 U 1 1 61CECBAC
 P 7850 4500
@@
 LPF
 $Comp
-L 70W-Amplifier-rescue:Inductor-Xenir L1
+L 70W-Amplifier-rescue:Inductor-Xenir-70W-Amplifier-rescue L1
 U 1 1 61D26F6D
 P 7850 4000
@@
 	6050 4350 6050 4250
 $Comp
-L 70W-Amplifier-rescue:Resistor-Xenir R6
+L 70W-Amplifier-rescue:Resistor-Xenir-70W-Amplifier-rescue R6
 U 1 1 61C90F87
 P 6400 4400
@@
 	6400 4950 6400 4600
 $Comp
-L 70W-Amplifier-rescue:Splitter_Center_Tap-Xenir T1
+L 70W-Amplifier-rescue:Splitter_Center_Tap-Xenir-70W-Amplifier-rescue T1
 U 1 1 61CE4121
 P 5000 3850
@@
 	5350 4850 5350 4950
 $Comp
-L 70W-Amplifier-rescue:2N3906-SMD-Xenir Q1
+L 70W-Amplifier-rescue:2N3906-SMD-Xenir-70W-Amplifier-rescue Q1
 U 1 1 61CF1527
 P 5300 1800
@@
 $EndComp
 $Comp
-L 70W-Amplifier-rescue:PCB_SMA_EDGE-Xenir J3
+L 70W-Amplifier-rescue:PCB_SMA_EDGE-Xenir-70W-Amplifier-rescue J3
 U 1 1 61CF5952
 P 9650 4350
@@
 $EndComp
 $Comp
-L 70W-Amplifier-rescue:PCB_SMA_EDGE-Xenir J4
+L 70W-Amplifier-rescue:PCB_SMA_EDGE-Xenir-70W-Amplifier-rescue J4
 U 1 1 61CF9C6B
 P 10500 4350
@@
 $EndComp
 $Comp
-L 70W-Amplifier-rescue:Splitter_Center_Tap-Xenir T2
+L 70W-Amplifier-rescue:Splitter_Center_Tap-Xenir-70W-Amplifier-rescue T2
 U 1 1 61CFF29A
 P 8550 5050
@@
 Q3Drain
 $Comp
-L 70W-Amplifier-rescue:Resistor-Xenir R8
+L 70W-Amplifier-rescue:Resistor-Xenir-70W-Amplifier-rescue R8
 U 1 1 61E660AB
 P 7150 4150
@@
 $EndComp
 $Comp
-L 70W-Amplifier-rescue:Resistor-Xenir R9
+L 70W-Amplifier-rescue:Resistor-Xenir-70W-Amplifier-rescue R9
 U 1 1 61E6F0FA
 P 7150 4750
@@
 $EndComp
 $Comp
-L 70W-Amplifier-rescue:Capacitor-Xenir C6
+L 70W-Amplifier-rescue:Capacitor-Xenir-70W-Amplifier-rescue C6
 U 1 1 61E6FCAB
 P 7100 4325
@@
 $EndComp
 $Comp
-L 70W-Amplifier-rescue:Capacitor-Xenir C7
+L 70W-Amplifier-rescue:Capacitor-Xenir-70W-Amplifier-rescue C7
 U 1 1 61E706E7
 P 7100 4550
@@
 	7350 4550 7350 4450
 $Comp
-L 70W-Amplifier-rescue:Capacitor-Xenir C8
+L 70W-Amplifier-rescue:Capacitor-Xenir-70W-Amplifier-rescue C8
 U 1 1 61E9AE04
 P 9050 4750
