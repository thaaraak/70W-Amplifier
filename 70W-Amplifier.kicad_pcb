# Repository thaaraak/70W-Amplifier

## KiCad design 70W-Amplifier.kicad_pcb

Parts:
C1, C2, C3, C8: .1uF; Capacitor 1206
C4, C5: .47uF; Capacitor 1206
C6, C7: .2uF; Capacitor 1206
D1: 1N4148; D_SOD-123
D2, D3, D4, D5, D6, D7: 1N914; D_SOD-123
EC1, EC2: 100uF; CP_Elec_6.3x7.7
J1: RF_OUT; BNC
J2: RF_IN; BNC
J3: LPF_IN; PCB-SMA-EDGE
J4: LPF_OUT; PCB-SMA-EDGE
J5: 13.8V Input; PowerConnectorPads
J6: PTT; TwoPads
J7: Conn_01x02; PinPad
J8: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
JP1: LPF Bypass; Jumper
K1: G5V-2; Relay_DPDT_Omron_G5V-2-SMD
L1: BN-43-202 2T; BN-43-202-Vertical-SMD
Q1: 2N3906-SMD; SOT-23
Q2, Q3: IRF530; TO-220-Horizontal
R1, R2, R3: 10k; Resistor 1206
R4, R5: 100; LargeResistorSurfaceMount
R6: Varies According to Band; LargeResistorSurfaceMount
R7: 180; Resistor 1206
R8, R9: .17; R_2512_6332Metric
T1: BN-43-202 1T:2T; BN-43-202-Splitter-SMD
T2: Ferrite 1T:3T; Ferrite-Tube-Splitter-SMD
U1: L7805; TO-252-3_TabPin2
VR1: 1.5k; Trimpot_Horizontal_SMD

Connections:
+12V: EC1.1, J5.2, L1.1, Q1.2 (E), R1.2
/Q2Drain: Q2.2 (D), R4.1, T2.5
/Q3Drain: Q3.2 (D), R5.1, T2.3
BIAS: C3.1, R3.2, T1.4, VR1.2
GND: C1.2, C2.2, C3.2, C6.1, C7.1, D1.2 (A), EC1.2, EC2.2, J1.GND, J2.GND, J3.2, J4.2, J5.1, J6.1, J7.2, K1.1, R3.1, R8.2, R9.2, T1.2, T2.2, U1.2 (GND), VR1.3
LPF: J4.1, JP1.2, K1.8
unnamed: C1.1, L1.2, T2.4
unnamed: C2.1, J7.1, R7.1, VR1.1
unnamed: C4.1, R4.2
unnamed: C4.2, Q2.1 (G), R6.2, T1.3
unnamed: C5.1, Q3.1 (G), R6.1, T1.5
unnamed: C5.2, R5.2
unnamed: C6.2, Q2.3 (S), R8.1
unnamed: C7.2, Q3.3 (S), R9.1
unnamed: C8.1, J3.1, JP1.1
unnamed: C8.2, T2.1
unnamed: D2.1 (K), D4.2 (A)
unnamed: D2.2 (A), J8.2
unnamed: D3.1 (K), J8.1
unnamed: D3.2 (A), D5.1 (K)
unnamed: D4.1 (K), D6.2 (A)
unnamed: D5.2 (A), D7.1 (K)
unnamed: D6.1 (K), D7.2 (A)
unnamed: EC2.1, R7.2, U1.3 (OUT)
unnamed: J1.S (OUT), K1.4
unnamed: J2.S (OUT), K1.13
unnamed: J6.2, R2.1
unnamed: K1.9, T1.1
unnamed: K1.6, K1.11
unnamed: Q1.1 (B), R1.1, R2.2
TRANSMIT_ON: D1.1 (K), K1.16, Q1.3 (C), U1.1 (IN)

Board: 2 copper layers, 127.5 x 68.0 mm, 44 parts (0 on the bottom side), 31 nets.

## Commit log

2021-12-29 added foot
2021-12-29 still going
2021-12-29 added splitter
2021-12-31 pcb work
2021-12-31 added resistors
2021-12-31 added source resistor/cap
2022-01-09 finished pcb
2022-01-09 changed to surface mount
2022-01-10 finished
2022-01-10 added gerber
2022-01-12 updated pdf
2022-01-18 test
2022-01-19 CHANGED BOARD SIZE
2022-01-19 Added vias
2022-01-19 fixed pnp wrong way around
2022-01-19 added pdf
2022-01-19 updated gerber
2022-01-19 added dc block cap
2022-01-19 added gerb
2022-01-20 added diode prot
2022-01-20 fixed diode
2022-01-20 changed diode to sod-123
2022-01-21 shrank board
2022-01-23 Update fp-info-cache
2022-07-26 addedf R6
2022-08-16 added
2022-08-16 added bom
